# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\gpio;..\HARDWARE\SysTick;..\HARDWARE\usart;..\HARDWARE\wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/gpio/: bsp_gpio.c
    ../HARDWARE/SysTick/: bsp_SysTick.c
    ../HARDWARE/usart/: bsp_usart1.c bsp_usart2.c
    ../HARDWARE/wifi/: wifi_config.c wifi_function.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c
  group DOC
    ../Doc/: wifi_function.txt 网页控制ESP8266.txt 引脚连接.txt
